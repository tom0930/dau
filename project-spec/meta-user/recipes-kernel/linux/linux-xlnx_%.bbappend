SRC_URI += "file://user_2021-10-16-22-34-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

